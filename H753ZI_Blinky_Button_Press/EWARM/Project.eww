<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\H753ZI_Blinky_Button_Press.ewp</path>
  </project>
  <batchBuild />
</workspace>
